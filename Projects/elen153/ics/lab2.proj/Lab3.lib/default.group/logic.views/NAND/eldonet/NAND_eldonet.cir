* Component: $Lab3/default.group/logic.views/NAND  Viewpoint: eldonet
.INCLUDE NAND_eldonet.spi

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX
