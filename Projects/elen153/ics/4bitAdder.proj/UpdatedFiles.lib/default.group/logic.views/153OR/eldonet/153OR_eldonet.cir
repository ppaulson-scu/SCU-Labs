* Component: $UpdatedFiles/default.group/logic.views/153OR  Viewpoint: eldonet
.INCLUDE 153OR_eldonet.spi

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX
